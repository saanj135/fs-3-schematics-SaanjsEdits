# Repository saanj135/fs-3-schematics-SaanjsEdits

## KiCad design ETC/ETC.kicad_pcb

Board: 2 copper layers, 42 parts (1 on the bottom side), 30 nets, no tracks yet.

Parts:
C1, C3: .33 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C4: .1 µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7: 40 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9, C14, C15: 100 nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11, C12, C13: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
P1: DTM1312PC12PDR008; TE_DTM1312PC12PDR008
R1, R5, R6, R8: 180kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R9: 330kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R7: 100kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R12: 10kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R13: 390kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14, R15: 120Ω; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R18: 1kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R19: 200kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: NUCLEO-F446RE
U2: MCP6004; N14
U3: LM7805_TO220; TO-220-3_Vertical
U4: LM7809_TO220; TO-220-3_Vertical
U5, U6: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U7: SN74AHC14N; N14

Connections:
+3V3: C10.1, C12.1, R10.1, R12.1, R16.1, R18.1, U1.CN7_16 (CN7_+3V3), U5.1 (VCC1), U6.1 (VCC1), U7.14 (VCC)
+5V: C2.1, C11.1, C13.1, P1.C9, P1.C10, P1.D8, U2.4 (V+), U3.3 (VO), U5.8 (VCC2), U6.8 (VCC2)
+9V: C4.1, U1.CN7_24 (CN7_VIN), U4.3 (VO)
+12V: C1.1, C3.1, P1.D5, U3.1 (VI), U4.1 (VI)
/BSE: C7.1, R8.2, R9.1, U1.CN7_38 (PC0/PB8)
/BSE_RAW: P1.D12, R7.1, U2.10 (+)
/CAN_RD: U1.CN10_29 (PB5), U6.2 (RXD)
/CAN_TD: U1.CN10_17 (PB6), U6.3 (TXD)
/Cockpit_Raw: P1.D11, R10.2, R11.2, R16.2, R17.2
/Cockpit_Signal: C14.1, R17.1, U1.CN7_31 (PH1), U7.2 (1Y)
/Cockpit_smooth: C8.1, R11.1, U7.1 (1A)
/HE1: C5.1, R1.2, R2.1, U1.CN7_28 (PA0)
/HE1_RAW: P1.C8, R3.1, U2.3 (+)
/HE2: C6.1, R5.2, R6.1, U1.CN7_34 (PB0)
/HE2_RAW: P1.C7, R4.1, U2.5 (+)
/H_CAN: P1.D3, R15.1, U6.7 (CANH)
/H_Motor_CAN: P1.D1, R14.1, U5.7 (CANH)
/L_CAN: P1.D4, R15.2, U6.6 (CANL)
/L_Motor_CAN: P1.D2, R14.2, U5.6 (CANL)
/Motor_CAN_RD: U1.CN10_14 (PA11), U5.2 (RXD)
/Motor_CAN_TD: U1.CN10_12 (PA12), U5.3 (TXD)
/RTDS: P1.D10, U1.CN7_23 (PC13)
/Reverse_Raw: P1.C1, R12.2, R13.2, R18.2, R19.2
/Reverse_Signal: C15.1, R19.1, U1.CN7_27 (PC15), U7.4 (2Y)
/Reverse_smooth: C9.1, R13.1, U7.3 (2A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, P1.C2, P1.C11, P1.C12, P1.D6, P1.D7, P1.D9, R2.2, R3.2, R4.2, R6.2, R7.2, R9.2, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND__1), U1.CN7_20 (CN7_GND__2), U1.CN7_22 (CN7_GND__3), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND__1), U1.CN10_32 (AGND), U2.11 (V-), U2.12 (+), U3.2 (GND), U4.2 (GND), U5.4 (GND1), U5.5 (GND2), U6.4 (GND1), U6.5 (GND2), U7.5 (3A), U7.7 (GND), U7.9 (4A), U7.11 (5A), U7.13 (6A)
unnamed: R1.1, U2.1, U2.2 (-)
unnamed: R5.1, U2.6 (-), U2.7
unnamed: R8.1, U2.8, U2.9 (-)
unnamed: U2.13 (-), U2.14

## Commit log

2024-10-19 working directory
